# Keil uVision project InfoBoard.uvprojx, settings and files
target STM32F051 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: InfoBoard +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F051,USE_DEFAULT_TIMEOUT_CALLBACK,
  c misc: --C99
  c include: C:\STM32F0xx_StdPeriph_Lib_V1.3.1\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\InfoBoard
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./: main.c USART_irq_func.c Check_T.c
  group std_periph
    C:/STM32F0xx_StdPeriph_Lib_V1.3.1/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group sys
    ./: stm32f0xx.h stm32f0xx_conf.h
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM0.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/STM32F051R8/: startup_stm32f051.s system_stm32f0xx.c
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Device:Startup 1.0.0
